# Keil uVision project mcos-gd32.uvprojx, settings and files
target MCOS-GD32 (5060960::V5.06 update 7 (build 960)::.\ACC5)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mcos-gd32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F407
  c include: ..\..\USER;..\..\Library\CMSIS\GD\GD32F4xx\Include;..\..\Library\GD32F4xx_standard_peripheral\Include;..\..\Library\CMSIS;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../../USER/: main.c sys_int.c gd32f4xx_it.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group GD32F4xx_StdPeriph_Driver
    ../../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_usart.c gd32f4xx_syscfg.c gd32f4xx_rcu.c gd32f4xx_pmu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_timer.c gd32f4xx_spi.c gd32f4xx_fwdgt.c gd32f4xx_fmc.c gd32f4xx_exmc.c gd32f4xx_can.c gd32f4xx_dbg.c
  group FreeRTOS/src
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
